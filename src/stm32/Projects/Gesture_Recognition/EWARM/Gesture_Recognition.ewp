# IAR project Gesture_Recognition.ewp, settings and files
configuration STM32F4-Discovery (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F407xx; USE_STM32F4_DISCO
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\; ..\Inc; ..\Src; ..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Source; ..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc; ..\..\..\Drivers\STM32F4xx_HAL_Driver\Src; ..\..\..\Drivers\BSP\STM32F4-Discovery
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Gesture_Recognition.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: ..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Source\Templates\iar\linker\stm32f407xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32F4-Discovery
    ../../../Drivers/BSP/STM32F4-Discovery/: stm32f4_discovery.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c
    ../../../Drivers/STM32F4xx_HAL_Driver/Inc/: stm32f4xx_hal.h
  group Projects/EWARM
    ./: startup_stm32f407xx.s
  group Projects/User
    ../Src/: main.c stm32f4xx_hal_timebase_tim.c stm32f4xx_it.c
